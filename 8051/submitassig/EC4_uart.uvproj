# Keil uVision project EC4_uart.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: EC4_uart +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.h lcd8bit.h uart.h prog.h EC4_uart.c
