# Keil uVision project UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: UART +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: u1.c u2.c u3_arry_enter_print-lcd.c u4.c u5_calculator.c calcmainup1flash.c clcmain.c u6_rfid.c
