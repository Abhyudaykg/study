# Keil uVision project I2C.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: I2C +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p1_eeprom.c delay.h i2c.h i2c_device.h lcd8bit.h p2_rtc.c EC_rtc.c
