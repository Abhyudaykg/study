# Keil uVision project Tall_plaza.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: Tall_plaza
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: EC_rtc.c p1_eeprom.c delay.h i2c.h i2c_device.h lcd8bit.h rtc_main.h uart.h
