# Keil uVision project da_acqu.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: da_acqu +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.h i2c.h i2c_device.h lcd8bit.h uart.h rtc_main.h main.c adcspi.h
