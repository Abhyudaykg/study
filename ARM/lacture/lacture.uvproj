# Keil uVision project lacture.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: lacture +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s p1.c delay.h lcd8bit.h lcd.c p2sw.c keypad.h p3_4x4kypad.c
    ./I2C/: EC_rtc.c p1_eeprom.c p2_rtc.c i2c.h i2c_device.h
